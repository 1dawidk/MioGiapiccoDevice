# Keil uVision project MioGiapicco.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103R6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MioGiapicco +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_LD, c99
  c include: ..\MioGiapicco;..\..\libs\BusDrv;..\..\libs\ExtFun;..\..\libs\HighDrv;..\..\libs\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\libs\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;..\..\libs\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Main
    ./: GlobalVar.c main.c
    ./fun/: fun.c esp8266Drv.c ServerDriver.c JSON.c WiFiMgr.c StaticMemoryDrv.c
  group LowPeriphDrv
    ../../libs/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_i2c.c
  group HighPeriphDrv
    ../../libs/HighDrv/: ADCHighDrv.c TimerHighDrv.c
    ../../libs/BusDrv/: DMADrv.c
    ../../libs/BusDrv/UART/: UartDrv.c UartDrv.h
    ../../libs/BusDrv/I2C/: I2cDrv.c I2cDrv.h
  group CoreDrv
    ./: stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h
    ./fun/: coreInit.c coreInit.h
  group RVMDK
    ./: mod_startup_stm32f10x_md.s
  group CMSIS
    ../../libs/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../../libs/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.h stm32f10x.h system_stm32f10x.c
